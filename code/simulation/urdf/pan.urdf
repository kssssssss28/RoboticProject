Commit message: first simulation

File: code/simulation/urdf/pan.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link right_leg: geometry collision cylinder length=0.03 radius=2; visual cylinder length=0.03 radius=2
